# Repository dgramop/SLI-HW

File README.md:

# SLI-HW
 Hardware files for Oakton High School's entry into NASA's Student Launch Initiative

## KiCad design SLI HW.kicad_pcb

Parts:
BT1: Battery_Cell; AA battery holder
C1, C4, C5, C6, C7: CAP; C_0805_2012Metric_Pad1.15x1.40mm_HandSolder
C2, C3: CAP 2.2uF; C_0805_2012Metric_Pad1.15x1.40mm_HandSolder
D1, D2, D3: LED; LED_0805_2012Metric_Pad1.15x1.40mm_HandSolder
D7: LED VCC; LED_0805_2012Metric_Pad1.15x1.40mm_HandSolder
J1: Boot bridge, GND; PinSocket_1x02_P2.54mm_Vertical
J2: Boot bridge, HIGH; PinSocket_1x02_P2.54mm_Vertical
J3: Boot bridge; PinSocket_1x02_P2.54mm_Vertical
J4: VCCboot; PinSocket_1x02_P2.54mm_Vertical
J5: GNDbootjumper; PinSocket_1x02_P2.54mm_Vertical
J6: PINboot; PinSocket_1x02_P2.54mm_Vertical
J7: Jumper for emergency wakeup; PinSocket_1x02_P2.54mm_Vertical
J9, J12: Micro_SD_Card; 1140084168
J10: Conn_01x07_Male; PinHeader_1x07_P2.54mm_Vertical
J13: VCC debug pin; PinHeader_1x01_P2.54mm_Vertical
J14: GND debug pin; PinHeader_1x01_P2.54mm_Vertical
J15: xdout; PinHeader_1x01_P2.54mm_Vertical
J16: DIO xbee; PinHeader_1x01_P2.54mm_Vertical
J17: PWM0 xbee; PinHeader_1x01_P2.54mm_Vertical
J20: DTR for xbee; PinHeader_1x01_P2.54mm_Vertical
J21: xdin; PinHeader_1x01_P2.54mm_Vertical
J24: AD1 xbee; PinHeader_1x01_P2.54mm_Vertical
J25: AD2 xbee; PinHeader_1x01_P2.54mm_Vertical
J26: AD3 xbee; PinHeader_1x01_P2.54mm_Vertical
J28: ASC xbee; PinHeader_1x01_P2.54mm_Vertical
J29: Conn_01x01_Female; PinHeader_1x01_P2.54mm_Vertical
J30: xbee ON/SLEEP; PinHeader_1x01_P2.54mm_Vertical
J32: xbee DIO4; PinHeader_1x01_P2.54mm_Vertical
J33: SWDCLK for sensor; PinHeader_1x01_P2.54mm_Vertical
J34: SWDIO for sensor; PinHeader_1x01_P2.54mm_Vertical
J36: SWDCLK for comms; PinHeader_1x01_P2.54mm_Vertical
J37: SWDIO for comms; PinHeader_1x01_P2.54mm_Vertical
J39: AccInt; PinHeader_1x01_P2.54mm_Vertical
J40: UART1TX; PinHeader_1x01_P2.54mm_Vertical
J41: UART1RX; PinHeader_1x01_P2.54mm_Vertical
J42: PA15 JTDI; PinHeader_1x01_P2.54mm_Vertical
J43: JTDO/TRACESWO; PinHeader_1x01_P2.54mm_Vertical
J44: I2C1SCL; PinHeader_1x01_P2.54mm_Vertical
J45: I2C1SDA; PinHeader_1x01_P2.54mm_Vertical
J46: UART6TX; PinHeader_1x01_P2.54mm_Vertical
J47: UART6RX; PinHeader_1x01_P2.54mm_Vertical
J48: UART4TX; PinHeader_1x01_P2.54mm_Vertical
J49: UART4RX; PinHeader_1x01_P2.54mm_Vertical
J50: PD0; PinHeader_1x01_P2.54mm_Vertical
J51: PD1; PinHeader_1x01_P2.54mm_Vertical
J52: PD2; PinHeader_1x01_P2.54mm_Vertical
J53: PD3; PinHeader_1x01_P2.54mm_Vertical
J54: PD4; PinHeader_1x01_P2.54mm_Vertical
J55: PD5; PinHeader_1x01_P2.54mm_Vertical
J56: PD6; PinHeader_1x01_P2.54mm_Vertical
J57: PD7; PinHeader_1x01_P2.54mm_Vertical
J66: SPI; PinHeader_1x03_P2.54mm_Vertical
J67: PA0; PinHeader_1x01_P2.54mm_Vertical
J68: P6; PinHeader_1x01_P2.54mm_Vertical
J69: P5; PinHeader_1x01_P2.54mm_Vertical
J70: P4; PinHeader_1x01_P2.54mm_Vertical
J71: P3; PinHeader_1x01_P2.54mm_Vertical
J72: P2; PinHeader_1x01_P2.54mm_Vertical
J73: P1; PinHeader_1x01_P2.54mm_Vertical
J74: PA1; PinHeader_1x01_P2.54mm_Vertical
J75: PA4; PinHeader_1x01_P2.54mm_Vertical
J79: PB0; PinHeader_1x01_P2.54mm_Vertical
R3, R4, R5, R6, R7, R8, R9, R10, R11, R17, R18, R20: R_US; R_0805_2012Metric_Pad1.15x1.40mm_HandSolder
SW1, SW2, SW3, SW4: SW_Push; PinHeader_1x02_P2.54mm_Vertical
SW5: SW_SPST; PinHeader_1x02_P2.54mm_Vertical
U1: ICM20948; QFN-24-1EP_3x3mm_P0.4mm_EP1.75x1.6mm
U2: STM32F205ZCTx; LQFP-144_20x20mm_P0.5mm
U3, U4: BMP388; PQFN50P200X200X80-10N
U5: STM32F103CT6; LQFP-48_7x7mm_P0.5mm
U6: ADA746; PinSocket_1x09_P2.54mm_Vertical
U7: Xbee; DIP2200W51P200L3294H279Q20P
U8: TCR2EE185-SOT553; SOT-553

Connections:
/205RX: J10.5, U2.70 (PB11), U5.42 (PB6)
/205TX: J10.6, U2.69 (PB10), U5.43 (PB7)
/AccInt: J39.1, U1.12
/CLKSD: J12.5 (CLK), U5.15 (PA5)
/CSA1: U2.26 (PC0), U3.6 (CSB)
/CSA2: U2.27 (PC1), U4.6 (CSB)
/CSA3: U1.22, U2.28 (PC2)
/CSA4: J9.2 (DAT3/CD), U2.29 (PC3)
/CSSD: J12.2 (DAT3/CD), U5.41 (PB5)
/DISD: J12.3 (CMD), U5.17 (PA7)
/DOSD: J12.7 (DAT0), U5.16 (PA6)
/GPSENABLE: U5.29 (PA8), U6.2 (EN)
/GPSFIX: U5.28 (PB15), U6.4 (FIX)
/GPSRX: U5.30 (PA9), U6.6 (RX)
/GPSTX: U5.31 (PA10), U6.5 (TX)
/MISO(SDO)f205: J9.7 (DAT0), J66.1, U1.9, U2.42 (PA6), U3.5 (SDO), U4.5 (SDO)
/MOSI(SDI)f205: J9.3 (CMD), J66.2, U1.24, U2.43 (PA7), U3.4 (SDI), U4.4 (SDI)
/PPS205: J10.7, U2.3 (PE4), U6.9 (PPS)
/SWCLK103: J36.1, R17.2, U5.37 (PA14)
/SWCLKsensor: J33.1, R10.2, U2.109 (PA14)
/SWDIO103: J37.1, R18.1, U5.34 (PA13)
/SWDIOsensor: J34.1, R11.1, U2.105 (PA13)
/boot0f103: J6.1, U5.44 (BOOT0)
/boot1f103: J6.2, U5.20 (PB2), U5.~
/f103wkup: J10.1, U2.5 (PE6), U5.10 (PA0-WKUP)
/f205sck: J9.5 (CLK), J66.3, U1.23, U2.41 (PA5), U3.2 (SCK), U4.2 (SCK)
/f205wkup: J10.2, J67.1, U2.34 (PA0), U5.45 (PB8)
/vddioacc: C7.1, U1.8, U8.4 (Vout)
/xdin: J21.1, U5.12 (PA2), U7.3 (DIN/CONFIG)
/xdout: J15.1, U5.13 (PA3), U7.2 (DOUT)
BOOT0: J3.1, U2.138 (BOOT0)
BOOT1: J3.2, U2.48 (PB2)
GND: BT1.2 (-), C1.2, C2.1, C3.2, C4.2, C5.2, C6.2, C7.2, D7.1 (K), J1.1, J1.2, J5.1, J5.2, J9.6 (VSS), J9.9 (SHIELD), J10.4, J12.6 (VSS), J12.9 (SHIELD), J14.1, R3.1, R4.1, R7.1, R8.1, R9.1, R10.1, R17.1, SW1.1, SW2.1, SW4.1, U1.11, U1.18, U1.20, U2.16 (VSS), U2.31 (VSSA), U2.38 (VSS), U2.51 (VSS), U2.61 (VSS), U2.83 (VSS), U2.94 (VSS), U2.107 (VSS), U2.120 (VSS), U2.130 (VSS), U3.3 (VSS), U3.8 (VSS), U3.9 (VSS), U4.3 (VSS), U4.8 (VSS), U4.9 (VSS), U5.8 (VSSA), U5.23 (VSS_1), U5.35 (VSS_2), U5.47 (VSS_3), U6.7 (GND), U7.10 (GND), U7.14 (VREF), U8.2 (GND)
unnamed: BT1.1 (+), SW5.2 (B)
unnamed: C2.2, U2.71 (VCAP_1)
unnamed: C3.1, U2.106 (VCAP_2)
unnamed: C4.1, R5.2, SW1.2, U2.25 (NRST)
unnamed: D1.1 (K), R3.2
unnamed: D1.2 (A), U2.2 (PE3)
unnamed: D2.1 (K), R8.2
unnamed: D2.2 (A), U5.26 (PB13)
unnamed: D3.1 (K), R9.2
unnamed: D3.2 (A), U5.25 (PB12)
unnamed: D7.2 (A), R20.1
unnamed: J7.2, R4.2, U2.1 (PE2)
unnamed: J16.1, U7.4 (DIO12)
unnamed: J17.1, U7.6 (PWM0/RSS/DIO10)
unnamed: J20.1, U7.9 (DTR/SLEEP_RQ/DIO8)
unnamed: J24.1, U7.19 (AD1/DIO1)
unnamed: J25.1, U7.18 (AD2/DIO2)
unnamed: J26.1, U7.17 (AD3/DIO3)
unnamed: J28.1, U7.15 (ASC/DIO5)
unnamed: J29.1, U1.10
unnamed: J30.1, U7.13 (ON/SLEEP)
unnamed: J32.1, U7.11 (DIO4)
unnamed: J40.1, U2.101 (PA9)
unnamed: J41.1, U2.102 (PA10)
unnamed: J42.1, U2.110 (PA15)
unnamed: J43.1, U2.133 (PB3)
unnamed: J44.1, U2.136 (PB6)
unnamed: J45.1, U2.137 (PB7)
unnamed: J46.1, U2.96 (PC6)
unnamed: J47.1, U2.97 (PC7)
unnamed: J48.1, U2.111 (PC10)
unnamed: J49.1, U2.112 (PC11)
unnamed: J50.1, U2.114 (PD0)
unnamed: J51.1, U2.115 (PD1)
unnamed: J52.1, U2.116 (PD2)
unnamed: J53.1, U2.117 (PD3)
unnamed: J54.1, U2.118 (PD4)
unnamed: J55.1, U2.119 (PD5)
unnamed: J56.1, U2.122 (PD6)
unnamed: J57.1, U2.123 (PD7)
unnamed: J68.1, U5.6 (OSC_OUT)
unnamed: J69.1, U5.5 (OSC_IN)
unnamed: J70.1, U5.4 (PC15-OSC32_OUT)
unnamed: J71.1, U5.3 (PC14-OSC32_IN)
unnamed: J72.1, U5.2 (PC13-TAMPER-RT_C)
unnamed: J73.1, U5.1 (VBAT)
unnamed: J74.1, U5.11 (PA1)
unnamed: J75.1, U5.14 (PA4)
unnamed: J79.1, U5.18 (PB0)
unnamed: R6.2, SW2.2, U5.7 (NRST)
unnamed: R7.2, SW3.1, U5.27 (PB14)
unnamed: SW4.2, U7.5 (RESET)
VCC: C1.1, C5.1, C6.1, J2.1, J2.2, J4.1, J4.2, J7.1, J9.4 (VDD), J10.3, J12.4 (VDD), J13.1, R5.1, R6.1, R11.2, R18.2, R20.2, SW3.2, SW5.1 (A), U1.13, U2.6 (VBAT), U2.17 (VDD), U2.30 (VDD), U2.32 (VREF+), U2.33 (VDDA), U2.39 (VDD), U2.52 (VDD), U2.62 (VDD), U2.72 (VDD), U2.84 (VDD), U2.95 (VDD), U2.108 (VDD), U2.121 (VDD), U2.131 (VDD), U2.144 (VDD), U3.1 (VDDIO), U3.10 (VDD), U4.1 (VDDIO), U4.10 (VDD), U5.9 (VDDA), U5.24 (VDD_1), U5.36 (VDD_2), U5.48 (VDD_3), U6.8 (VIN), U7.1 (VCC), U8.1 (control), U8.3 (Vin)

Notes on the sheet:
Sensor & Comms boards
maybe have a separate battery?
VDDIO voltage divider?
can put a transistor to shut off voltage divider
verify that 3.6 is operating voltage and not
most sd cards are ok with 3.6 volts if they follow the official spec. worst case, we may need to bring voltage from the 3.3 pin on the gps
put a pullup on xbee rset? seems to have internal pullup
VREF+ and VDDA want a better, more stable power source! Check their voltage then delete this!!
Where is VREF-? Is it connected here in the scheme?
have multiple connections that can wire-or wakeup pin 34?
will need pullups to I2C!! and maybe other busses depending on if they’re open drain etc
ICM-20948 VDDIO range is 1.71V to 1.95V
Before you connect checklist - proper configuration of voltage regulators - battery & other power sources disconnected
USB should output 3.6V and allow regulation by battery
decoupling cap?

Board: 2 copper layers, 90.0 x 125.0 mm, 94 parts (1 on the bottom side), 82 nets.
